## Kconfig
```kconfig
menu "KBOX support"

comment "KBOX Driver is ......."

config KBOX
	tristate "KBOX support"
	help
	  This is kbox driver.

endmenu
```
